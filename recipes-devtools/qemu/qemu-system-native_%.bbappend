PACKAGECONFIG:append:class-native = " virtfs"
